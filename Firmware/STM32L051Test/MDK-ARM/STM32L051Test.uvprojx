# Keil uVision project STM32L051Test.uvprojx, settings and files
target STM32L051Test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L051K8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L051Test
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c misc: --C99
  c include: ../../../../Inc;   C:/Users/andy1/STM32Cube/Repository/STM32Cube_FW_L0_V1.8.0/Drivers/STM32L0xx_HAL_Driver/Inc;   C:/Users/andy1/STM32Cube/Repository/STM32Cube_FW_L0_V1.8.0/Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;   C:/Users/andy1/STM32Cube/Repository/STM32Cube_FW_L0_V1.8.0/Drivers/CMSIS/Device/ST/STM32L0xx/Include;   C:/Users/andy1/STM32Cube/Repository/STM32Cube_FW_L0_V1.8.0/Drivers/CMSIS/Include;   ../Inc;   ..\MenuItem
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L0xx_HAL_Driver
    C:/Users/andy1/STM32Cube/Repository/STM32Cube_FW_L0_V1.8.0/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rcc.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_tim.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c
  group Application/User
    ../Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c HCMS29xx.c HCMS29xx_Util.c l_simple_queue.c menu_logic.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Menu
    ../Src/: menu_l3_RPN_entry.c
    ../MenuItem/: menu_l0_lptime.c menu_l0_lptime.h menu_l1_time.c menu_l1_time.h menu_l2_apps.c menu_l2_apps.h menu_l3_config.c menu_l3_config.h menu_l3_RPN.c menu_l3_RPN.h
software components: CMSIS:CORE 4.1.0
